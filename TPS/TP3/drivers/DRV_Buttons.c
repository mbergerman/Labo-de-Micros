/***************************************************************************//**
  @file     DRV_Buttons.c
  @brief    +Descripcion del archivo+
  @author   matia
 ******************************************************************************/

/*******************************************************************************
 * INCLUDE HEADER FILES
 ******************************************************************************/

#include "DRV_Buttons.h"
#include "DRV_ShiftRegister.h"

/*******************************************************************************
 * CONSTANT AND MACRO DEFINITIONS USING #DEFINE
 ******************************************************************************/

#define LEFT_SHIFT	5
#define RIGHT_SHIFT 7
#define STATE_SHIFT 6

#define RIGHT_VAL(x)	((x >> RIGHT_SHIFT) & 0x01)
#define LEFT_VAL(x)		((x >> LEFT_SHIFT) & 0x01)
#define STATE_VAL(x)	((x >> STATE_SHIFT) & 0x01)

/*******************************************************************************
 * ENUMERATIONS AND STRUCTURES AND TYPEDEFS
 ******************************************************************************/


/*******************************************************************************
 * VARIABLES WITH GLOBAL SCOPE
 ******************************************************************************/

// +ej: unsigned int anio_actual;+


/*******************************************************************************
 * FUNCTION PROTOTYPES FOR PRIVATE FUNCTIONS WITH FILE LEVEL SCOPE
 ******************************************************************************/

// +ej: static void falta_envido (int);+


/*******************************************************************************
 * ROM CONST VARIABLES WITH FILE LEVEL SCOPE
 ******************************************************************************/

// +ej: static const int temperaturas_medias[4] = {23, 26, 24, 29};+


/*******************************************************************************
 * STATIC VARIABLES AND CONST VARIABLES WITH FILE LEVEL SCOPE
 ******************************************************************************/

static uint8_t data;

/*******************************************************************************
 *******************************************************************************
                        GLOBAL FUNCTION DEFINITIONS
 *******************************************************************************
 ******************************************************************************/

void initButtons(){
	ShiftRegister_init();
}


SR_button_t getButtonPressed()
{
	SR_button_t ret = BUTTON_NONE;

	data = ShiftRegister_read();

	if (RIGHT_VAL(data) && !LEFT_VAL(data) && !STATE_VAL(data))
	{
		ret = BUTTON_RIGHT;
	}
	else if (!RIGHT_VAL(data) && LEFT_VAL(data) && !STATE_VAL(data))
	{
		ret = BUTTON_LEFT;
	}
	else if (!RIGHT_VAL(data) && !LEFT_VAL(data) && STATE_VAL(data))
	{
		ret = BUTTON_STATE;
	}

	return ret;

}

/*******************************************************************************
 *******************************************************************************
                        LOCAL FUNCTION DEFINITIONS
 *******************************************************************************
 ******************************************************************************/
 
